options:
  parameters:
    category: Packet Operators
    generate_options: qt_gui
    id: new_packet_rx
    output_language: python
    title: Packetized RX with FEC
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.45'
  states: {state: disabled}
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Amplitude
    start: '0'
    step: '0.005'
    stop: '0.9'
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: |-
      Represents the time raster to ensure that packet
      allignment works ideally should should leading 
      columns gaps indicating low BER.
    rangeType: int
    start: '0'
    step: '1'
    stop: '40000'
    value: '200'
  states: {}
- name: hdr_dec
  id: variable_dummy_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, constellation.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: mark_delay
  id: variable
  parameters:
    value: mark_delays[sps]
  states: {}
- name: mark_delays
  id: variable
  parameters:
    comment: |-
      Tag Marking Delay for 
      Corr Est block, indexed
      by sps.

      Found empirically.
    value: '[0, 0, 34, 56, 87, 119]'
  states: {}
- name: modulated_sync_word
  id: variable_modulate_vector
  parameters:
    data: preamble
    mod: rxmod
    taps: '[1]'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: pld_dec
  id: variable_repetition_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {state: disabled}
- name: pld_dec
  id: variable_dummy_decoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: pld_dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: polyphase_loop_bandwidth
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: preamble
  id: variable
  parameters:
    value: preamble_select[int(1.0/hdr_dec.rate())]
  states: {}
- name: preamble_dummy
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Dummy
    value: '[0xac, 0xdd, 0xa4, 0xe2, 0xf2, 0x8c, 0x20, 0xfc]'
  states: {}
- name: preamble_rep
  id: variable
  parameters:
    comment: |-
      use when header
      FEC is Repetition (x3)
    value: '[0xe3, 0x8f, 0xc0, 0xfc, 0x7f, 0xc7, 0xe3, 0x81, 0xc0, 0xff, 0x80, 0x38, 0xff, 0xf0, 0x38, 0xe0, 0x0f, 0xc0, 0x03, 0x80, 0x00, 0xff, 0xff, 0xc0]'
  states: {}
- name: preamble_select
  id: variable
  parameters:
    value: '{1: preamble_dummy, 3: preamble_rep}'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: rxmod
  id: variable
  parameters:
    value: digital.generic_mod(constellation, False, sps, True, alpha, False, False)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {state: disabled}
- name: alpha
  id: parameter
  parameters:
    label: Filter Rolloff
    type: eng_float
    value: '0.35'
  states: {}
- name: blocks_message_debug_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_by_tag_value_cc_0
  id: blocks_multiply_by_tag_value_cc
  parameters:
    tagname: '"amp_est"'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: constellation.bits_per_symbol()
    lengthtagname: '"payload symbols"'
    type: float
  states: {}
- name: digital_constellation_soft_decoder_cf_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constellation
    npwr: '-1'
  states: {}
- name: digital_constellation_soft_decoder_cf_0_0
  id: digital_constellation_soft_decoder_cf
  parameters:
    constellation: constellation
    npwr: '-1'
  states: {}
- name: digital_corr_est_cc_0
  id: digital_corr_est_cc
  parameters:
    mark_delay: mark_delay
    sps: sps
    symbols: modulated_sync_word
    threshold: '0.999'
    threshold_method: digital.THRESHOLD_ABSOLUTE
  states: {}
- name: digital_costas_loop_cc_0_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 6.28/200.0
  states: {}
- name: digital_costas_loop_cc_0_0_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 6.28/200.0
  states: {}
- name: digital_crc32_async_bb_0
  id: digital_crc32_async_bb
  parameters:
    check: 'True'
  states: {}
- name: digital_header_payload_demux_0
  id: digital_header_payload_demux
  parameters:
    header_len: (hdr_format.header_nbits() * int(1.0/hdr_dec.rate())) //  constellation.bits_per_symbol()
    header_padding: '0'
    items_per_symbol: '1'
    length_tag_key: '"payload symbols"'
    output_symbols: 'True'
    samp_rate: '1'
    special_tags: '[]'
    timing_tag_key: '"rx_time"'
    trigger_tag_key: '"time_est"'
    type: complex
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: polyphase_loop_bandwidth
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: digital_protocol_parser_b_0
  id: digital_protocol_parser_b
  parameters:
    format: hdr_format
  states: {}
- name: fec_async_decoder_0
  id: fec_async_decoder
  parameters:
    decoder: pld_dec
    mtu: 1500*8
    packed: 'True'
    rev_pack: 'False'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    decoder: hdr_dec
    itype: float
    otype: byte
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: pkt out
    optional: 'True'
    type: message
  states: {state: disabled}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: precrc
    optional: 'True'
    type: message
  states: {state: disabled}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: hdr_out
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_3
  id: pad_sink
  parameters:
    label: pld_out
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_3_0
  id: pad_sink
  parameters:
    label: pld_phs
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_5
  id: pad_sink
  parameters:
    label: timing
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_sink_7
  id: pad_sink
  parameters:
    label: corr est
    optional: 'True'
    type: complex
  states: {state: disabled}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: complex
  states: {}
- name: pdu_tagged_stream_to_pdu_0
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: '"payload symbols"'
    type: float
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    label1: Corr Estimator
    label2: Polyphase
    name: '"Constellation"'
    nconnections: '2'
    size: '4096'
    type: complex
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}

connections:
- [blocks_multiply_by_tag_value_cc_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', pdu_tagged_stream_to_pdu_0, '0']
- [digital_constellation_soft_decoder_cf_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [digital_constellation_soft_decoder_cf_0_0, '0', fec_generic_decoder_0, '0']
- [digital_corr_est_cc_0, '0', blocks_multiply_by_tag_value_cc_0, '0']
- [digital_corr_est_cc_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_corr_est_cc_0, '1', blocks_null_sink_0, '0']
- [digital_corr_est_cc_0, '1', pad_sink_7, '0']
- [digital_costas_loop_cc_0_0, '0', digital_constellation_soft_decoder_cf_0_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', digital_constellation_soft_decoder_cf_0, '0']
- [digital_costas_loop_cc_0_0_0, '0', pad_sink_3_0, '0']
- [digital_crc32_async_bb_0, out, blocks_message_debug_0_0_0, print]
- [digital_crc32_async_bb_0, out, pad_sink_0, in]
- [digital_header_payload_demux_0, '0', digital_costas_loop_cc_0_0, '0']
- [digital_header_payload_demux_0, '0', pad_sink_2, '0']
- [digital_header_payload_demux_0, '1', digital_costas_loop_cc_0_0_0, '0']
- [digital_header_payload_demux_0, '1', pad_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_header_payload_demux_0, '0']
- [digital_pfb_clock_sync_xxx_0, '0', pad_sink_5, '0']
- [digital_pfb_clock_sync_xxx_0, '0', qtgui_const_sink_x_1_0, '1']
- [digital_pfb_clock_sync_xxx_0, '1', blocks_null_sink_3, '0']
- [digital_pfb_clock_sync_xxx_0, '2', blocks_null_sink_2, '0']
- [digital_pfb_clock_sync_xxx_0, '3', blocks_null_sink_1, '0']
- [digital_protocol_parser_b_0, info, digital_header_payload_demux_0, header_data]
- [fec_async_decoder_0, out, digital_crc32_async_bb_0, in]
- [fec_async_decoder_0, out, pad_sink_1, in]
- [fec_generic_decoder_0, '0', digital_protocol_parser_b_0, '0']
- [pad_source_0, '0', digital_corr_est_cc_0, '0']
- [pdu_tagged_stream_to_pdu_0, pdus, fec_async_decoder_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.12.0
