options:
  parameters:
    generate_options: qt_gui
    id: comms_project_rx
    output_language: python
    title: Packetized MPEG Receiver
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: after_correlate_tag
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1600'
    value: '192'
  states: {state: disabled}
- name: after_crc
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '1600'
    value: '188'
  states: {state: disabled}
- name: agc_rate
  id: variable_qtgui_range
  parameters:
    comment: 5,2,1,1
    gui_hint: 5,2,1,1
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1e-4'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.99'
  states: {}
- name: bps
  id: variable
  parameters:
    value: constellation.bits_per_symbol()
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cfo_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      This is used to artificially introduce
      CFO to verify that the FFL is doing
      coarse CFO correction
    gui_hint: 0,0,1,4
    start: '-200e3'
    step: '1'
    stop: 200e3
    value: '0'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 16QAM constellation
    precision: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16]'
    type: 16qam
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 16QAM constellation
    const_points: numpy.exp(1j* numpy.radians(numpy.arange(0, 360, 22.5)))
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[10, 11, 0, 1, 2, 3, 4, 5, 6, 7, 12, 13, 14, 15, 8, 9]'
    type: calcdist
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: |-
      Base
       4QAM constellation
    precision: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16]'
    type: qpsk
  states: {state: disabled}
- name: costas_loop_bandwidth_in_cycles_per_sample
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: crc_size
  id: variable
  parameters:
    comment: CRC is 4 Bytes
    value: '4'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: packet_and_crc
  states: {}
- name: frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: |-
      Represents the time raster to ensure that packet
      allignment works ideally should should leading 
      columns gaps indicating low BER.
    rangeType: int
    start: '0'
    step: '1'
    stop: '1600'
    value: '392'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, thresh, bps)
  states: {}
- name: k
  id: variable
  parameters:
    comment: 1/2
    value: '7'
  states: {}
- name: k
  id: variable
  parameters:
    value: '5'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_and_crc
  id: variable
  parameters:
    value: packet_length+crc_size
  states: {}
- name: packet_groups
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_length
  id: variable
  parameters:
    comment: |-
      Group together multiple packets
      to prevent flooding of PDU queue
    value: packet_groups*ts_packet_size
  states: {}
- name: polys
  id: variable
  parameters:
    comment: 1/2
    value: '[109, 79]'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[25, 27]'
  states: {state: disabled}
- name: rate
  id: variable
  parameters:
    value: len(polys)
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4.5e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '1'
  states: {}
- name: timing_error_loop_bandwith
  id: variable_qtgui_range
  parameters:
    comment: 5,3,1,1
    gui_hint: 5,3,1,1
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.045'
  states: {}
- name: ts_packet_size
  id: variable
  parameters:
    value: '188'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: agc_rate
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cfo_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {state: disabled}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_1_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0_1_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: '"packet_len"'
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi*costas_loop_bandwidth_in_cycles_per_sample
  states: {}
- name: digital_crc32_bb_0_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[-1, 1]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      If using Polyphase Ffilterbank, MF, it does the
      matched filtering for you, but you need to 
      pass in properly constructed RRC filter taps
      TODO: try the others, but with explicit RRC matched filtering
         don't bother with M&M
    constellation: constellation
    damping: '1.0'
    loop_bw: timing_error_loop_bandwith
    max_dev: '.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: fec_extended_tagged_decoder_0
  id: fec_extended_tagged_decoder
  parameters:
    decoder_list: dec_cc
    lentagname: '"packet_len"'
    mtu: '1000'
    puncpat: '''11'''
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '5000'
    send_eof: 'False'
    type: byte
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    comment: 5,0,2,2
    gui_hint: 5,0,2,2
    label1: Sync
    label2: Costas
    name: '"Symbol Sink and Costas"'
    nconnections: '2'
    size: '4096'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"black"'
    color2: '"blue"'
    fc: '0'
    fftsize: 1024*8
    gui_hint: 1,0,1,2
    label1: Receive Raw
    label2: Received with Artificial CFO
    label3: Receive FLL Band-Edge
    name: '"RX Spectrum Raw, CFO, and CFO-Corrected"'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0_1_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 7,0,1,2
    name: '"Packet Out Frames Bits"'
    ncols: frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 7,2,1,2
    name: '"Packet Out Frames Bytes"'
    ncols: frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmax: '255'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    comment: Has 192 bytes now in the syncronization
    name: '"After Correlate Bits"'
    ncols: after_correlate_tag*8
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"After CRC"'
    ncols: after_crc*8
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"After Access Code"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"After CRC"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 10,0,1,4
    gui_hint: 10,0,1,4
    label1: Sync T_inst
    label2: Sync T_avg
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Frequency
    label2: Phase
    label3: Error
    nconnections: '3'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 8,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Raw Decisions Unpacked"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_2_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 8,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    name: '"Received Payload after Correlate"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"FEC Decoded Payload"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,2,1,2
    name: '"Received Frequency Raster"'
    type: complex
  states: {}
- name: virtual_sink_1_0_3
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_differential
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_differential
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_1, '0', fec_extended_tagged_decoder_0, '0']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_repack_bits_bb_0_2, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_repack_bits_bb_0_2, '0', digital_crc32_bb_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', blocks_uchar_to_float_0_0_1_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', digital_crc32_bb_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0_1_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0_1, '0', blocks_uchar_to_float_1, '0']
- [blocks_repack_bits_bb_1_0_1, '0', blocks_uchar_to_float_0_0_1_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', qtgui_time_raster_sink_x_0_1_0_0, '0']
- [blocks_skiphead_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_1, '0']
- [blocks_uchar_to_float_0_0_1_0, '0', qtgui_time_sink_x_0_2_0_0, '0']
- [blocks_uchar_to_float_0_0_1_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_1_0_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_uchar_to_float_0_0_1_0_0_1, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_uchar_to_float_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_1_0, '0', qtgui_time_sink_x_1_0, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', blocks_uchar_to_float_0_0_1_0_0_1, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', virtual_sink_1_0_3, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0_1, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', digital_map_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0_1, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1_0, '1']
- [digital_costas_loop_cc_0, '1', blocks_null_sink_2, '0']
- [digital_costas_loop_cc_0, '1', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0_0, '0']
- [digital_costas_loop_cc_0, '2', blocks_null_sink_3, '0']
- [digital_costas_loop_cc_0, '2', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0_0, '1']
- [digital_costas_loop_cc_0, '3', blocks_null_sink_1, '0']
- [digital_costas_loop_cc_0, '3', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0_0, '2']
- [digital_crc32_bb_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', blocks_uchar_to_float_0_0_1_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', network_udp_sink_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '2']
- [digital_map_bb_0, '0', blocks_char_to_float_1, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_symbol_sync_xx_0, '1', blocks_null_sink_0_1, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '0']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '1']
- [fec_extended_tagged_decoder_0, '0', blocks_repack_bits_bb_0_2, '0']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1_0_0, '0', blocks_repack_bits_bb_1_0_1, '0']
- [virtual_source_1_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
