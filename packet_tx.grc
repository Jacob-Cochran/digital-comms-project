options:
  parameters:
    category: Packet Operators
    generate_options: qt_gui
    id: new_packet_tx
    output_language: python
    title: Packetized Transmit with FEC
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.45'
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: Amplitude
    start: '0'
    step: '0.005'
    stop: '0.9'
    value: '0.5'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    const_points: digital.psk_4()[0]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_4()[1]
    type: calcdist
  states: {}
- name: frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: |-
      Represents the time raster to ensure that packet
      allignment works ideally should should leading 
      columns gaps indicating low BER.
    rangeType: int
    start: '0'
    step: '1'
    stop: '40000'
    value: '200'
  states: {}
- name: hdr_enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, constellation.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: packet_groups
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_length
  id: variable
  parameters:
    comment: |-
      Group together multiple packets
      to prevent flooding of PDU queue
    value: packet_groups*ts_packet_size
  states: {}
- name: pld_enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {state: disabled}
- name: pld_enc
  id: variable_dummy_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
  states: {state: disabled}
- name: pld_enc
  id: variable_cc_encoder_def
  parameters:
    framebits: 1500*8
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: rep
  id: variable
  parameters:
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: ts_packet_size
  id: variable
  parameters:
    value: '188'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: ./test_video/mp4sample.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Rate limits the the file source
      so that it doesn't overload
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'False'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    format: hdr_format
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import pmt

      class blk(gr.basic_block):
          def __init__(self, packet_len=188):
              gr.basic_block.__init__(
                  self,
                  name="pdu_chunker",
                  in_sig=[np.uint8],
                  out_sig=None,
              )

              self.packet_len = int(packet_len)
              self.buffer = bytearray()

              # add message output port
              self.message_port_register_out(pmt.intern("in"))

          def general_work(self, input_items, output_items):
              data = input_items[0]

              # append incoming data to buffer
              self.buffer.extend(data.tolist())

              # process full packets
              while len(self.buffer) >= self.packet_len:
                  chunk = self.buffer[:self.packet_len]
                  del self.buffer[:self.packet_len]

                  # create PDU
                  vec = pmt.init_u8vector(self.packet_len, chunk)
                  meta = pmt.make_dict()

                  # publish the PDU
                  self.message_port_pub(pmt.intern("in"), pmt.cons(meta, vec))

              # consume all input data
              self.consume(0, len(data))
              return 0
    packet_len: packet_length
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import pmt
      from gnuradio import gr

      class blk(gr.basic_block):
          """
          Generic PDU forwarder:
          Forwards messages from input_port_name → output_port_name
          """
          def __init__(self, input_port_name="in", output_port_name="pdus"):
              gr.basic_block.__init__(self,
                  name="pdu_forwarder",
                  in_sig=None,
                  out_sig=None
              )

              self.input_port_name = input_port_name
              self.output_port_name = output_port_name

              # register dynamic ports
              self.message_port_register_in(pmt.intern(self.input_port_name))
              self.message_port_register_out(pmt.intern(self.output_port_name))

              # set handler
              self.set_msg_handler(pmt.intern(self.input_port_name), self.handle_msg)

          def handle_msg(self, msg):
              # forward the message unchanged
              self.message_port_pub(pmt.intern(self.output_port_name), msg)
    input_port_name: '''out'''
    output_port_name: '''pdus'''
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: pld_enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: fec_async_encoder_0_0
  id: fec_async_encoder
  parameters:
    encoder: hdr_enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: iio_pluto_sink_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: payload
    tag: packet_len
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    comment: header
    tag: packet_len
    type: byte
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 28,0
    name: '"Transmit Frames Bits"'
    ncols: frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_1_0_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 29,0
    name: '" Transmit Frames Bytes"'
    ncols: frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmax: '255'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 31,0
    label1: Transmit re
    label2: Transmit im
    marker1: '0'
    marker2: '0'
    name: '"Transmit Time Domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: sps
  id: parameter
  parameters:
    label: Samples per Symbol
    type: eng_float
    value: '2'
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: pkt_bytes
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    comment: |-
      Feed packet bytes into
      the constellation modulator
    stream_id: pkt_bytes
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_1_0_0, '0']
- [blocks_throttle2_0, '0', epy_block_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_crc32_async_bb_1, out, fec_async_encoder_0, in]
- [digital_protocol_formatter_async_0, header, fec_async_encoder_0_0, in]
- [digital_protocol_formatter_async_0, payload, pdu_pdu_to_tagged_stream_0, pdus]
- [epy_block_0, in, digital_crc32_async_bb_1, in]
- [epy_block_1, pdus, pdu_pdu_to_tagged_stream_0_0, pdus]
- [fec_async_encoder_0, out, digital_protocol_formatter_async_0, in]
- [fec_async_encoder_0_0, out, epy_block_1, in]
- [pdu_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [pdu_pdu_to_tagged_stream_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [virtual_source_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
