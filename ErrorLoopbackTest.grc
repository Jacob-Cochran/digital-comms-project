options:
  parameters:
    generate_options: hb
    id: error_loopback_test
    output_language: python
    title: Failed FEC Loopback
  states: {}

blocks:
- name: pkt_fec
  id: variable_ccsds_encoder_def
  parameters:
    comment: |-
      We're going to pass CRC + payload 
      into the FEC, that way at the receiver we
      can fix the CRC and header. Then if the
      CRC fails after FEC we drop the full packet
    framebits: 8*(packet_length+4)
    mode: fec.CC_TERMINATED
    ndim: '0'
    state_start: '0'
  states: {}
- name: pkt_fec_dec
  id: variable_repetition_decoder_def
  parameters:
    framebits: 8*(packet_length+4)
    ndim: '0'
    prob: '0.5'
    rep: '3'
  states: {}
- name: pkt_fec_enc
  id: variable_repetition_encoder_def
  parameters:
    framebits: 8*(packet_length+4)
    ndim: '0'
    rep: '3'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_2
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_0_2_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_uchar_to_float_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: fec_tagged_decoder_0
  id: fec_tagged_decoder
  parameters:
    decoder: pkt_fec_dec
    lentagname: '"packet_len"'
    mtu: '4000'
  states: {}
- name: fec_tagged_encoder_0
  id: fec_tagged_encoder
  parameters:
    encoder: pkt_fec_enc
    lentagname: '"packet_len"'
    mtu: '4000'
  states: {}
- name: packet_length
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out_floats
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: out_bytes
    type: byte
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: corrected_payload_time
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: payload_bytes
    type: byte
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [blocks_repack_bits_bb_0_2, '0', blocks_uchar_to_float_1_0, '0']
- [blocks_repack_bits_bb_0_2, '0', pad_sink_0_0, '0']
- [blocks_repack_bits_bb_0_2_0, '0', fec_tagged_decoder_0, '0']
- [blocks_uchar_to_float_1, '0', pad_sink_1, '0']
- [blocks_uchar_to_float_1_0, '0', pad_sink_0, '0']
- [fec_tagged_decoder_0, '0', blocks_repack_bits_bb_0_2, '0']
- [fec_tagged_encoder_0, '0', blocks_null_sink_0, '0']
- [fec_tagged_encoder_0, '0', blocks_repack_bits_bb_0_2_0, '0']
- [fec_tagged_encoder_0, '0', blocks_uchar_to_float_1, '0']
- [pad_source_0, '0', fec_tagged_encoder_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
