options:
  parameters:
    generate_options: qt_gui
    id: comms_project_tx
    output_language: python
    title: Packetized MPEG Transmitter
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.99'
  states: {}
- name: bps
  id: variable
  parameters:
    value: constellation.bits_per_symbol()
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 16QAM constellation
    precision: '8'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15, 16]'
    type: 16qam
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 16QAM constellation
    const_points: |-
      [-0.9486832980505138-0.9486832980505138j,
       -0.31622776601683794-0.9486832980505138j,
        0.31622776601683794-0.9486832980505138j,
        0.9486832980505138-0.9486832980505138j,

       -0.9486832980505138-0.31622776601683794j,
       -0.31622776601683794-0.31622776601683794j,
        0.31622776601683794-0.31622776601683794j,
        0.9486832980505138-0.31622776601683794j,

       -0.9486832980505138+0.31622776601683794j,
       -0.31622776601683794+0.31622776601683794j,
        0.31622776601683794+0.31622776601683794j,
        0.9486832980505138+0.31622776601683794j,

       -0.9486832980505138+0.9486832980505138j,
       -0.31622776601683794+0.9486832980505138j,
        0.31622776601683794+0.9486832980505138j,
        0.9486832980505138+0.9486832980505138j]
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]'
    type: calcdist
  states: {state: disabled}
- name: crc_size
  id: variable
  parameters:
    comment: CRC is 4 Bytes
    value: '4'
  states: {}
- name: dec_cc
  id: variable_cc_decoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: frame_size*8
    k: k
    mode: fec.CC_STREAMING
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: frame_size
  id: variable
  parameters:
    value: packet_and_crc
  states: {}
- name: frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: header_format_default
    start: '0'
    step: '1'
    stop: '2000'
    value: '392'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, thresh, bps)
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: packet_and_crc
  id: variable
  parameters:
    value: packet_length+crc_size
  states: {}
- name: packet_groups
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_length
  id: variable
  parameters:
    comment: |-
      Group together multiple packets
      to prevent flooding of PDU queue
    value: packet_groups*ts_packet_size
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: rate
  id: variable
  parameters:
    value: '2'
  states: {}
- name: raw_data_sync
  id: variable_qtgui_range
  parameters:
    rangeType: int
    start: '0'
    step: '1'
    stop: '40000'
    value: '188'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(4.5e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ts_packet_size
  id: variable
  parameters:
    value: '188'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '0'
  states: {}
- name: video_file
  id: variable
  parameters:
    value: '"./video.ts"'
  states: {state: disabled}
- name: video_file
  id: variable
  parameters:
    value: '"./test_video/mp4sample.ts"'
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: video_file
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (188, 188)
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_length
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate/10
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_1_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_1_1_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: numpy.tile(numpy.arange(188, dtype=numpy.uint8), 1000).tolist()
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: numpy.zeros(188, dtype=numpy.uint8).tolist()
  states: {state: disabled}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_protocol_formatter_bb_0_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: fec_extended_tagged_encoder_0_0
  id: fec_extended_tagged_encoder
  parameters:
    encoder_list: enc_cc
    lentagname: '"packet_len"'
    mtu: '1000'
    puncpat: '''11'''
  states: {}
- name: iio_pluto_sink_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_udp_source_0
  id: network_udp_source
  parameters:
    header: '0'
    ipv6: 'False'
    notify_missed: 'False'
    payloadsize: packet_length
    port: '5000'
    src_zeros: 'False'
    type: byte
  states: {}
- name: puncpat
  id: parameter
  parameters:
    value: '''11'''
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 28,0
    name: '"Transmit Frames Bits"'
    ncols: frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_1_0_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 29,0
    name: '" Transmit Frames Bytes"'
    ncols: frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmax: '255'
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Packet Bits"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Full Packet with Header"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 31,0
    label1: Transmit re
    label2: Transmit im
    marker1: '0'
    marker2: '0'
    name: '"Transmit Time Domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Payload with FEC"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_1_1
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Payload No FEC Yes CRC"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1_1_2
  id: qtgui_time_sink_x
  parameters:
    name: '"TX Final PKT Bytes"'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '256'
    ymin: '0'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: payload_bytes
  states: {}
- name: virtual_sink_0_0_0
  id: virtual_sink
  parameters:
    stream_id: header_bytes
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: fec_payload_bytes
  states: {}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: pkt_bytes
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    comment: |-
      Feed packet bytes into
      the constellation modulator
    stream_id: pkt_bytes
  states: {}
- name: virtual_source_0_0_0_0
  id: virtual_source
  parameters:
    comment: |-
      This is the simulated RX chain after 
      demodulation, etc and packetization
    stream_id: header_bytes
  states: {}
- name: virtual_source_0_0_0_0_0
  id: virtual_source
  parameters:
    comment: |-
      Bytes of the payload with tags
      and CRC before adding FEC
    stream_id: payload_bytes
  states: {}
- name: virtual_source_0_0_1
  id: virtual_source
  parameters:
    stream_id: fec_payload_bytes
  states: {}

connections:
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0_0, '0', fec_extended_tagged_encoder_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0_0_0, '0', blocks_uchar_to_float_1_1, '0']
- [blocks_repack_bits_bb_1_0_0_0_0_0_0, '0', virtual_sink_1, '0']
- [blocks_stream_mux_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_uchar_to_float_1_1_2, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_1_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_1_1, '0', qtgui_time_sink_x_1_1, '0']
- [blocks_uchar_to_float_1_1_1, '0', qtgui_time_sink_x_1_1_1, '0']
- [blocks_uchar_to_float_1_1_2, '0', qtgui_time_sink_x_1_1_2, '0']
- [blocks_vector_source_x_0, '0', blocks_stream_mux_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_stream_mux_0, '1']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_crc32_bb_0_0, '0', virtual_sink_0, '0']
- [digital_protocol_formatter_bb_0_0, '0', virtual_sink_0_0_0, '0']
- [fec_extended_tagged_encoder_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0_0_0, '0']
- [network_udp_source_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [virtual_source_0_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [virtual_source_0_0_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [virtual_source_0_0_0, '0', digital_constellation_modulator_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0_0_0, '0']
- [virtual_source_0_0_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0_0_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0_0, '0']
- [virtual_source_0_0_0_0_0, '0', blocks_uchar_to_float_1_1_1, '0']
- [virtual_source_0_0_1, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0_1, '0', digital_protocol_formatter_bb_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
