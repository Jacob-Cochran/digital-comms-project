options:
  parameters:
    generate_options: hb
    id: base_code_correlator
    output_language: python
    title: Basic Access Code Correlator
  states: {}

blocks:
- name: access_key
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: tag_name
  states: {}
- name: blocks_repack_bits_bb_1_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: tag_name
    threshold: thresh
    type: byte
  states: {}
- name: digital_crc32_bb_0_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: tag_name
    packed: 'True'
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_sink_2_0
  id: pad_sink
  parameters:
    label: crc_out
    type: float
  states: {}
- name: pad_source_2
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: tag_name
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: thresh
  id: parameter
  parameters:
    value: '0'
  states: {}

connections:
- [blocks_char_to_float_0, '0', pad_sink_2_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', digital_crc32_bb_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', blocks_char_to_float_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', pad_sink_2, '0']
- [pad_source_2, '0', blocks_repack_bits_bb_1_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
