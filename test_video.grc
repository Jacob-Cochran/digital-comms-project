options:
  parameters:
    author: jcochran
    description: Simple test video to ensure input is encoded well to view it use $ mkfifo /tmp/test.ts     then $ ffplay /tmp/test.ts
    generate_options: qt_gui
    id: test_video
    output_language: python
    title: Test Video Loopback
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: int(4e6)
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/jcochran/comms/test_video/mp4sample.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
