options:
  parameters:
    generate_options: qt_gui
    id: packetized_loopback_test
    output_language: python
    title: Full TX/RX Loopback with Video
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.50'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cfo_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      This is used to artificially introduce
      CFO to verify that the FFL is doing
      coarse CFO correction
    gui_hint: 6,0
    label: Artificial CFO (Hz)
    start: '-500e3'
    step: '1'
    stop: 500e3
    value: '0'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: costas_loop_bandwidth_in_cycles_per_sample
  id: variable_qtgui_range
  parameters:
    gui_hint: 21,0
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '.01'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, 0)
  states: {}
- name: in_frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: |-
      Represents the time raster to ensure that packet
      allignment works ideally should should leading 
      columns gaps indicating low BER.
    rangeType: int
    start: '0'
    step: '1'
    stop: '40000'
    value: '200'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: out_frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: |-
      Represents the time raster to ensure that packet
      allignment works ideally should should leading 
      columns gaps indicating low BER.
    rangeType: int
    start: '0'
    step: '1'
    stop: '40000'
    value: '200'
  states: {}
- name: output_sps
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_groups
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_length
  id: variable
  parameters:
    comment: |-
      Group together multiple packets
      to prevent flooding of PDU queue
    value: packet_groups*ts_packet_size
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '70'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ts_packet_size
  id: variable
  parameters:
    value: '188'
  states: {}
- name: tx_attenuation
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: tx_attenuation_0
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '89'
    value: '10'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cfo_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/jcochran/comms/test_video/mp4sample.ts
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.3'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1j'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: math.e**(2j*math.pi*0)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_1
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: int
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_1_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: int
  states: {state: disabled}
- name: blocks_packed_to_unpacked_xx_1_0_0_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: int
  states: {state: disabled}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_1_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_1_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_1_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: packet_length
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    comment: |-
      Rate limits the the file source
      so that it doesn't overload
    samples_per_second: samp_rate
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_2
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0_1_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Input comes from Symbol Sync
      Includes a Costas Loop to do phase sync
    constellation: constellation
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi/100
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: '""'
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: '""'
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: '""'
    threshold: '0'
    type: byte
  states: {}
- name: digital_correlate_access_code_xx_ts_0_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: '""'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi*costas_loop_bandwidth_in_cycles_per_sample
  states: {}
- name: digital_crc32_bb_0
  id: digital_crc32_bb
  parameters:
    check: 'False'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_crc32_bb_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_crc32_bb_0_0_1
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {state: disabled}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0_0_1
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      Filterbank Arms: nfilts
      PFB MF Taps: rcc_taps
      Changed Maximum Deviation to 0.1 because 
      the clocks aren't more off than 0.1 samples per symbol
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '0.1'
    nfilters: nfilts
    osps: output_sps
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: iio_pluto_sink_0_0_0
  id: iio_pluto_sink
  parameters:
    attenuation1: tx_attenuation
    bandwidth: int(samp_rate)
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    comment: makes most sense if "Output Samples/Symbol" is 1
    gui_hint: 13,0
    label1: Symbol Sync
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: makes most sense if "Output Samples/Symbol" is 1
    gui_hint: 17,0
    label1: after Symbol Sync
    label2: after Costas
    nconnections: '2'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    label1: Sync
    label2: Costas
    name: '"Received Constellation Raw and Synchronized"'
    nconnections: '2'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 12,0
    label1: Eye Diagram for Receive Symbol Sync Re
    label2: Eye Diagram for Receive Symbol Sync  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_eye_sink_x_0_0_0
  id: qtgui_eye_sink_x
  parameters:
    gui_hint: 16,0
    label1: Eye Diagram after Costas Re
    label2: Eye Diagram after Costas  Im
    marker1: '0'
    marker2: '0'
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"black"'
    color2: '"blue"'
    fc: '0'
    fftsize: 1024*8
    label1: Receive Raw
    label2: Received with Artificial CFO
    label3: Receive FLL Band-Edge
    name: '"RX Spectrum Raw, CFO, and CFO-Corrected"'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 28,0
    name: '"Transmit Frames"'
    ncols: in_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out Frames"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out Frames"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out Frames"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_1
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out Frames"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_1_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 29,0
    label1: Input Symbols
    name: '"Phase Ambiguity #1"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_1_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 30,0
    label1: Input Symbols
    name: '"Phase Ambiguity #3"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_1_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 30,1
    label1: Input Symbols
    name: '"Phase Ambiguity #4'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_1_0_2
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 29,1
    label1: Input Symbols
    name: '"Phase Ambiguity #2"'
    ncols: out_frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 11,0
    label1: Receive Symbol Sync Re
    label2: Receive Symbol Sync Im
    size: 10*sps
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 18,0
    label1: Receive after Costas Re
    label2: Receive after Costas Im
    marker1: '0'
    marker2: '0'
    size: '100'
    srate: samp_rate/sps*output_sps
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: Sync T_inst
    label2: Sync T_avg
    name: '"Symbol Sync Erorr"'
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 1,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 31,0
    label1: Transmit re
    label2: Transmit im
    marker1: '0'
    marker2: '0'
    name: '"Transmit Time Domain"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 31,1
    label1: Transmit re
    label2: Transmit im
    marker1: '0'
    marker2: '0'
    name: '"RX Time Domain After Costas"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_2
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color4: blue
    comment: 1,0,1,2
    label1: Choice 1
    label2: Choice 2
    label3: Choice 3
    label4: Choice 4
    name: Correlate input
    nconnections: '4'
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    color4: blue
    comment: 1,0,1,2
    label1: Choice 1
    label2: Choice 2
    label3: Choice 3
    label4: Choice 4
    name: Correlate Output
    nconnections: '4'
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_1
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 1,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: 14,0
    label1: Sync error
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 15,0
    label1: Sync T_inst
    label2: Sync T_avg
    nconnections: '2'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1
  id: qtgui_time_sink_x
  parameters:
    alpha1: '0.5'
    gui_hint: 19,0
    label1: Costas error
    label2: Costas frequency [rad/samp]
    nconnections: '2'
    size: '10000'
    srate: samp_rate/sps*output_sps
    type: float
    width2: '2'
    ymax: '0.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 20,0
    label1: Costas phase
    size: '10000'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '7'
    ymin: '-7'
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 22,0
    label1: 0 phase rotation
    marker1: '0'
    size: '50'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '3.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0
  id: qtgui_time_sink_x
  parameters:
    color1: red
    gui_hint: 23,0
    label1: 1/4 cycle (90 deg) phase rotation
    marker1: '0'
    size: '50'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '3.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: green
    gui_hint: 24,0
    label1: 1/2 cycle (180 deg) phase rotation
    marker1: '0'
    size: '50'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '3.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color1: black
    gui_hint: 25,0
    label1: 3/4 cycle (270 deg) phase rotation
    marker1: '0'
    size: '50'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '3.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: qtgui_time_sink_x_2_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 27,0
    label1: differential with 0 phase rotation
    label2: differential with 1/4 cycle (90 deg) phase rotation
    label3: differential with 1/2 cycle (180 deg) phase rotation
    label4: differential with 3/4 cycle (270 deg) phase rotation
    marker1: '0'
    nconnections: '4'
    size: '25'
    srate: samp_rate/sps*output_sps
    type: float
    ymax: '3.5'
    ymin: '-0.5'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: payload_bytes
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: header_bytes
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes
  states: {state: disabled}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: pkt_bytes
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_1
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_2
  states: {}
- name: virtual_sink_5
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_3
  states: {}
- name: virtual_sink_8
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_4
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: payload_bytes
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    comment: |-
      This is the simulated RX chain after 
      demodulation, etc and packetization
    stream_id: header_bytes
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    comment: |-
      Feed packet bytes into
      the constellation modulator
    stream_id: pkt_bytes
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_4
  states: {}
- name: virtual_source_1_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_3
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_1
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_2
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_2, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_2_0, '0']
- [blocks_char_to_float_0_0_0, '0', qtgui_time_sink_x_2_0_0, '0']
- [blocks_char_to_float_0_0_0_0, '0', qtgui_time_sink_x_2_0_0_0, '0']
- [blocks_char_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_2_1, '3']
- [blocks_char_to_float_0_0_0_1, '0', qtgui_time_sink_x_2_1, '2']
- [blocks_char_to_float_0_0_1, '0', qtgui_time_sink_x_2_1, '1']
- [blocks_char_to_float_0_1, '0', qtgui_time_sink_x_2_1, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', iio_pluto_sink_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_1, '0']
- [blocks_multiply_const_vxx_1, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_pack_k_bits_bb_0, '0', virtual_sink_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_repack_bits_bb_1, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_repack_bits_bb_1_0, '0', digital_correlate_access_code_xx_ts_0_0, '0']
- [blocks_repack_bits_bb_1_0_0, '0', digital_crc32_bb_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0, '0', digital_crc32_bb_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', digital_crc32_bb_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_0_1, '0', digital_crc32_bb_0_0_1, '0']
- [blocks_repack_bits_bb_1_0_1, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_repack_bits_bb_1_1, '0', digital_correlate_access_code_xx_ts_0_1, '0']
- [blocks_skiphead_0, '0', digital_symbol_sync_xx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_crc32_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', virtual_sink_1_0_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_2_0_0_0, '3']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0, '0', qtgui_time_sink_x_0_2_0_0_0_0, '3']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_0, '0', qtgui_time_sink_x_0_2_0_0_0_0, '2']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_1, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_2_0_0_0_0, '0']
- [blocks_uchar_to_float_0_0_0_1, '0', qtgui_time_sink_x_0_0_0_1, '0']
- [blocks_uchar_to_float_0_0_0_1, '0', qtgui_time_sink_x_0_2_0_0_0_0, '1']
- [blocks_uchar_to_float_0_0_1, '0', qtgui_time_sink_x_0_2_0, '0']
- [blocks_uchar_to_float_0_0_1, '0', qtgui_time_sink_x_0_2_0_0_0, '2']
- [blocks_uchar_to_float_0_0_1_0, '0', qtgui_time_sink_x_0_2_0_0, '0']
- [blocks_uchar_to_float_0_0_1_0, '0', qtgui_time_sink_x_0_2_0_0_0, '0']
- [blocks_uchar_to_float_0_0_2, '0', qtgui_time_sink_x_0_2_0_0_0, '1']
- [blocks_uchar_to_float_0_0_2, '0', qtgui_time_sink_x_0_2_1, '0']
- [blocks_unpack_k_bits_bb_0_0, '0', virtual_sink_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', qtgui_time_raster_sink_x_1_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', virtual_sink_2, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', qtgui_time_raster_sink_x_1_0_1, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1, '0', virtual_sink_8, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_0, '0', qtgui_time_raster_sink_x_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_0, '0', virtual_sink_5, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_1, '0', qtgui_time_raster_sink_x_1_0_2, '0']
- [blocks_unpack_k_bits_bb_0_0_0_1_1, '0', virtual_sink_3, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', digital_constellation_modulator_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_char_to_float_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_char_to_float_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_char_to_float_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1_1, '0']
- [digital_constellation_decoder_cb_0_0, '0', digital_diff_decoder_bb_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_char_to_float_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_char_to_float_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1_0, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', digital_diff_decoder_bb_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_char_to_float_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_unpack_k_bits_bb_0_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', digital_diff_decoder_bb_0_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_1, '1']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_repack_bits_bb_1_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_uchar_to_float_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_repack_bits_bb_1_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0, '0', blocks_uchar_to_float_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_1, '0', blocks_repack_bits_bb_1_0_0_1, '0']
- [digital_correlate_access_code_xx_ts_0_1, '0', blocks_uchar_to_float_0_0_0_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0, '1']
- [digital_costas_loop_cc_0, '0', qtgui_eye_sink_x_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_0_0_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_time_sink_x_0_1_0, '0']
- [digital_costas_loop_cc_0, '1', qtgui_time_sink_x_1_1, '1']
- [digital_costas_loop_cc_0, '2', qtgui_time_sink_x_1_1_0, '0']
- [digital_costas_loop_cc_0, '3', qtgui_time_sink_x_1_1, '0']
- [digital_crc32_bb_0, '0', digital_protocol_formatter_bb_0, '0']
- [digital_crc32_bb_0, '0', virtual_sink_0, '0']
- [digital_crc32_bb_0_0, '0', blocks_file_sink_0, '0']
- [digital_crc32_bb_0_0_0, '0', blocks_file_sink_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_crc32_bb_0_0_1, '0', blocks_file_sink_0_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_char_to_float_0_1, '0']
- [digital_diff_decoder_bb_0_0_0, '0', blocks_char_to_float_0_0_1, '0']
- [digital_diff_decoder_bb_0_0_0_0, '0', blocks_char_to_float_0_0_0_0_0, '0']
- [digital_diff_decoder_bb_0_0_0_1, '0', blocks_char_to_float_0_0_0_1, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '2']
- [digital_protocol_formatter_bb_0, '0', virtual_sink_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_eye_sink_x_0_0, '0']
- [digital_symbol_sync_xx_0_0, '0', qtgui_time_sink_x_0_0_0_0_0, '0']
- [digital_symbol_sync_xx_0_0, '1', qtgui_time_sink_x_1, '0']
- [digital_symbol_sync_xx_0_0, '2', qtgui_time_sink_x_1_0, '0']
- [digital_symbol_sync_xx_0_0, '3', qtgui_time_sink_x_1_0, '1']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_0, '0', blocks_tagged_stream_mux_0, '1']
- [virtual_source_0_0, '0', blocks_tagged_stream_mux_0, '0']
- [virtual_source_0_0_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [virtual_source_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [virtual_source_0_0_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [virtual_source_1, '0', blocks_repack_bits_bb_1, '0']
- [virtual_source_1, '0', blocks_uchar_to_float_0_0, '0']
- [virtual_source_1, '0', qtgui_time_raster_sink_x_0_1, '0']
- [virtual_source_1_0, '0', blocks_repack_bits_bb_1_0, '0']
- [virtual_source_1_0, '0', blocks_uchar_to_float_0_0_1, '0']
- [virtual_source_1_0, '0', qtgui_time_raster_sink_x_0_1_0, '0']
- [virtual_source_1_0_0, '0', blocks_repack_bits_bb_1_0_1, '0']
- [virtual_source_1_0_0, '0', blocks_uchar_to_float_0_0_1_0, '0']
- [virtual_source_1_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0, '0']
- [virtual_source_1_1, '0', blocks_repack_bits_bb_1_1, '0']
- [virtual_source_1_1, '0', blocks_uchar_to_float_0_0_2, '0']
- [virtual_source_1_1, '0', qtgui_time_raster_sink_x_0_1_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
