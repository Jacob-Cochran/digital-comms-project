options:
  parameters:
    generate_options: qt_gui
    id: comms_project_rx
    output_language: python
    title: Packetized MPEG Receiver
  states: {}

blocks:
- name: access_key
  id: variable
  parameters:
    value: '''11100001010110101110100010010011'''
  states: {}
- name: agc_rate
  id: variable_qtgui_range
  parameters:
    comment: 5,2,1,1
    gui_hint: 5,2,1,1
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '1e-4'
  states: {}
- name: alpha
  id: variable
  parameters:
    comment: |-
      Can't change alpha in real time
      for Consteallation Modulator
    value: '0.45'
  states: {}
- name: bps
  id: variable
  parameters:
    value: constellation.bits_per_symbol()
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cfo_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      This is used to artificially introduce
      CFO to verify that the FFL is doing
      coarse CFO correction
    gui_hint: 0,0,1,4
    start: '-200e3'
    step: '1'
    stop: 200e3
    value: '200'
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {state: disabled}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 4QAM constellation
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: constellation
  id: variable_constellation
  parameters:
    comment: Differentially encoded 16PSK constellation
    const_points: '[1.000000 + 0.000000j,0.923880 + 0.382683j,0.707107 + 0.707107j,0.382683 + 0.923880j,0.000000 + 1.000000j,-0.382683 + 0.923880j,-0.707107 + 0.707107j,-0.923880 + 0.382683j,-1.000000 + 0.000000j,-0.923880 + -0.382683j,-0.707107 + -0.707107j,-0.382683 + -0.923880j,-0.000000 + -1.000000j,0.382683 + -0.923880j,0.707107 + -0.707107j,0.923880 + -0.382683j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '16'
    sym_map: '[10, 11, 0, 1, 2, 3, 4, 5, 6, 7, 12, 13, 14, 15, 8, 9]'
    type: calcdist
  states: {state: disabled}
- name: costas_loop_bandwidth_in_cycles_per_sample
  id: variable_qtgui_range
  parameters:
    gui_hint: 6,2,1,2
    start: '0.0001'
    step: '0.0001'
    stop: '0.2'
    value: '0.01'
  states: {}
- name: frame_sync_cols
  id: variable_qtgui_range
  parameters:
    comment: |-
      Represents the time raster to ensure that packet
      allignment works ideally should should leading 
      columns gaps indicating low BER.
    rangeType: int
    start: '0'
    step: '1'
    stop: '1600'
    value: 12+packet_length
  states: {}
- name: hdr_format
  id: variable
  parameters:
    comment: header_format_default
    value: digital.header_format_default(access_key, thresh, bps)
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_groups
  id: variable
  parameters:
    value: '1'
  states: {}
- name: packet_length
  id: variable
  parameters:
    comment: |-
      Group together multiple packets
      to prevent flooding of PDU queue
    value: packet_groups*ts_packet_size
  states: {}
- name: rcc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: alpha
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*samp_rate
    sym_rate: samp_rate/sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: sps
  id: variable
  parameters:
    value: '16'
  states: {}
- name: thresh
  id: variable
  parameters:
    value: '0'
  states: {}
- name: timing_error_loop_bandwith
  id: variable_qtgui_range
  parameters:
    comment: 5,3,1,1
    gui_hint: 5,3,1,1
    start: '0'
    step: '0.0001'
    stop: '1'
    value: '0.045'
  states: {}
- name: ts_packet_size
  id: variable
  parameters:
    value: '188'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: agc_rate
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: cfo_offset
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: base_code_correlator_0
  id: base_code_correlator
  parameters:
    access_key: access_key
    tag_name: '"packet_len_1"'
    thresh: thresh
  states: {state: disabled}
- name: base_code_correlator_0_0
  id: base_code_correlator
  parameters:
    access_key: access_key
    tag_name: '"packet_len_2"'
    thresh: thresh
  states: {state: disabled}
- name: base_code_correlator_0_0_0
  id: base_code_correlator
  parameters:
    access_key: access_key
    tag_name: '"packet_len_3"'
    thresh: thresh
  states: {state: disabled}
- name: base_code_correlator_0_0_0_0
  id: base_code_correlator
  parameters:
    access_key: access_key
    tag_name: '"packet_len_4"'
    thresh: thresh
  states: {state: disabled}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /tmp/test.ts
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: 1j
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1j'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '-1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1_1
  id: blocks_multiply_const_vxx
  parameters:
    const: math.e**(2j*math.pi*0)
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_null_sink_0_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_1
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_2
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_2_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_2_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_4_2_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_repack_bits_bb_1_0_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_repack_bits_bb_1_0_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skip one second of samples
      to allow AGC and FLL to lock
    num_items: int(samp_rate)
    type: complex
  states: {}
- name: blocks_uchar_to_float_0_0_0_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_uchar_to_float_0_0_1_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: constellation.bits_per_symbol()
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_0_2
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: constellation.bits_per_symbol()
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: correlate_and_crc_validate_0
  id: correlate_and_crc_validate
  parameters:
    access_key: access_key
    tag_name: '"packet_len_1"'
    thresh: thresh
  states: {state: disabled}
- name: correlate_and_crc_validate_0_0
  id: correlate_and_crc_validate
  parameters:
    access_key: access_key
    tag_name: '"packet_len_2"'
    thresh: thresh
  states: {state: disabled}
- name: correlate_and_crc_validate_0_0_0
  id: correlate_and_crc_validate
  parameters:
    access_key: access_key
    tag_name: '"packet_len_4"'
    thresh: thresh
  states: {state: disabled}
- name: correlate_and_crc_validate_0_1
  id: correlate_and_crc_validate
  parameters:
    access_key: access_key
    tag_name: '"packet_len_3"'
    thresh: thresh
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_decoder_cb_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0_0_0_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {state: disabled}
- name: digital_constellation_receiver_cb_0
  id: digital_constellation_receiver_cb
  parameters:
    comment: |-
      Input comes from Symbol Sync
      Includes a Costas Loop to do phase sync
    constellation: constellation
    fmax: math.pi
    fmin: '-math.pi'
    loop_bw: 2*math.pi/100
  states: {state: disabled}
- name: digital_correlate_access_code_xx_ts_0_0_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: access_key
    tagname: '"packet_len"'
    threshold: thresh
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: constellation.arity()
    w: 2*math.pi*costas_loop_bandwidth_in_cycles_per_sample
  states: {}
- name: digital_crc32_bb_0_0_0_0
  id: digital_crc32_bb
  parameters:
    check: 'True'
    lengthtagname: '"packet_len"'
    packed: 'True'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {state: disabled}
- name: digital_diff_decoder_bb_0_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: constellation.arity()
  states: {}
- name: digital_fll_band_edge_cc_0
  id: digital_fll_band_edge_cc
  parameters:
    filter_size: sps*2+1
    rolloff: alpha
    samps_per_sym: sps
    type: cc
    w: 2*math.pi/sps/100/sps
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    comment: |-
      If using Polyphase Ffilterbank, MF, it does the
      matched filtering for you, but you need to 
      pass in properly constructed RRC filter taps
      TODO: try the others, but with explicit RRC matched filtering
         don't bother with M&M
    constellation: constellation
    damping: '1.0'
    loop_bw: timing_error_loop_bandwith
    max_dev: '.1'
    nfilters: nfilts
    osps: '1'
    pfb_mf_taps: rcc_taps
    resamp_type: digital.IR_PFB_MF
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      #!/usr/bin/env python3
      # -*- coding: utf-8 -*-
      from gnuradio import gr
      import numpy as np

      class ts_file_writer_crc_stream(gr.basic_block):
          """
          Unwrap packets from Stream CRC32 (Check Mode) byte stream
          and write MPEG-TS packets to a file.
          """

          def __init__(self, header_len=12, ts_packet_size=188, crc_len=4, filename="/tmp/video.ts"):
              gr.basic_block.__init__(
                  self,
                  name="ts_file_writer_crc_stream",
                  in_sig=[np.uint8],
                  out_sig=[]
              )
              self.header_len = header_len
              self.ts_packet_size = ts_packet_size
              self.crc_len = crc_len
              self.packet_len = header_len + ts_packet_size + crc_len
              self.filename = filename

              self.buffer = bytearray()
              self.f = open(self.filename, "wb")

          def general_work(self, input_items, output_items):
              in0 = input_items[0]
              self.buffer.extend(in0.tobytes())

              while len(self.buffer) >= self.packet_len:
                  pkt = self.buffer[:self.packet_len]
                  self.buffer = self.buffer[self.packet_len:]

                  ts_payload = pkt[self.header_len:self.header_len+self.ts_packet_size]
                  self.f.write(ts_payload)

              self.f.flush()
              self.consume(0, len(in0))
              return 0

          def stop(self):
              self.f.close()
              return True
    crc_len: '4'
    filename: '"/tmp/test.ts"'
    header_len: '12'
    ts_packet_size: '200'
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: int(center_freq)
    gain1: '''slow_attack'''
    len_tag_key: ''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate)
    type: fc32
    uri: 192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,4
    label1: Sync
    label2: Costas
    name: '"Symbol Sink and Costas"'
    nconnections: '2'
    size: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    comment: 5,0,2,2
    gui_hint: 5,0,2,2
    label1: Sync
    label2: Costas
    name: '"Symbol Sink and Costas"'
    nconnections: '2'
    size: '4096'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"black"'
    color2: '"blue"'
    fc: '0'
    fftsize: 1024*8
    gui_hint: 1,0,1,2
    label1: Receive Raw
    label2: Received with Artificial CFO
    label3: Receive FLL Band-Edge
    name: '"RX Spectrum Raw, CFO, and CFO-Corrected"'
    nconnections: '3'
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Unpacked Raster"'
    ncols: '1024'
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 7,0,1,2
    name: '"Packet Out Frames Bits"'
    ncols: frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_1_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    gui_hint: 7,2,1,2
    name: '"Packet Out Frames Bytes"'
    ncols: frame_sync_cols
    nrows: '64'
    samp_rate: samp_rate
    type: byte
    zmax: '255'
    zmin: '0'
  states: {}
- name: qtgui_time_raster_sink_x_0_1_0_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out #1 Frames Bits"'
    ncols: out_frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: float
    zmax: '255'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out #2 Frames Bits"'
    ncols: out_frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: float
    zmax: '255'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0_0_0_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out #4 Frames Bits"'
    ncols: out_frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: float
    zmax: '255'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0_1_0_0_0_0_1
  id: qtgui_time_raster_sink_x
  parameters:
    name: '"Packet Out #3 Frames Bits"'
    ncols: out_frame_sync_cols*8
    nrows: '64'
    samp_rate: samp_rate
    type: float
    zmax: '255'
    zmin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 21,0
    label1: Constellation Receiver Decoded
    marker1: '0'
    name: '"Char to Float"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: constellation.arity()-1+0.2
    ymin: '-.2'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 10,0,1,4
    gui_hint: 10,0,1,4
    label1: Sync T_inst
    label2: Sync T_avg
    nconnections: '2'
    size: 1024*8
    srate: samp_rate
    type: float
    ymax: sps*1.01
    ymin: sps*0.99
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    gui_hint: 9,0,1,4
    label1: Constellation Receiver Decoded
    marker1: '0'
    name: '"CRC Out"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '500'
    ymin: '-500'
  states: {}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Constellation Receiver Decoded
    marker1: '0'
    name: '"CRC Out #1"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '500'
    ymin: '-500'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Constellation Receiver Decoded
    marker1: '0'
    name: '"CRC Out #2"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '500'
    ymin: '-500'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Constellation Receiver Decoded
    marker1: '0'
    name: '"CRC Out #4"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '500'
    ymin: '-500'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0_1
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    label1: Constellation Receiver Decoded
    marker1: '0'
    name: '"CRC Out #3"'
    size: '100'
    srate: samp_rate
    type: float
    ymax: '500'
    ymin: '-500'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0_1
  id: qtgui_time_sink_x
  parameters:
    comment: 1,2,1,2
    gui_hint: 8,2,1,2
    label1: ''
    name: Correlate Output
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_0_0
  id: qtgui_time_sink_x
  parameters:
    comment: 1,0,1,2
    gui_hint: 8,0,1,2
    label1: ''
    name: Correlate input
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {}
- name: qtgui_time_sink_x_0_2_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color3: magenta
    color4: dark green
    label1: '#1'
    label2: '#2'
    label3: '#3'
    label4: '#4'
    name: All Correlate Inputs
    nconnections: '4'
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_2_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color3: magenta
    color4: dark green
    label1: '#1'
    label2: '#2'
    label3: '#3'
    label4: '#4'
    name: All Correlate Inputs
    nconnections: '4'
    size: '256'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.2'
    tr_tag: '"packet_len"'
    type: float
    ymax: '1.1'
    ymin: '-0.1'
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: center_freq
    fftsize: '1024'
    gui_hint: 1,2,1,2
    name: '"Received Frequency Raster"'
    type: complex
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes
  states: {state: disabled}
- name: virtual_sink_1_0
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_1
  states: {state: disabled}
- name: virtual_sink_1_0_0
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_4
  states: {state: disabled}
- name: virtual_sink_1_0_1
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_2
  states: {state: disabled}
- name: virtual_sink_1_0_2
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_3
  states: {state: disabled}
- name: virtual_sink_1_0_3
  id: virtual_sink
  parameters:
    stream_id: pkt_out_bytes_differential
  states: {}
- name: virtual_source_1_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_differential
  states: {}
- name: virtual_source_1_0_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_1
  states: {state: disabled}
- name: virtual_source_1_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_2
  states: {state: disabled}
- name: virtual_source_1_0_0_0_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_4
  states: {state: disabled}
- name: virtual_source_1_0_0_0_1
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_3
  states: {state: disabled}
- name: virtual_source_1_0_0_0_2
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_1
  states: {state: disabled}
- name: virtual_source_1_0_0_0_2_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_2
  states: {state: disabled}
- name: virtual_source_1_0_0_0_2_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_3
  states: {state: disabled}
- name: virtual_source_1_0_0_0_2_0_0_0
  id: virtual_source
  parameters:
    stream_id: pkt_out_bytes_4
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_fll_band_edge_cc_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [base_code_correlator_0, '0', blocks_null_sink_4_2, '0']
- [base_code_correlator_0, '1', qtgui_time_sink_x_0_2_0_0_0_0, '0']
- [base_code_correlator_0_0, '0', blocks_null_sink_4_2_0, '0']
- [base_code_correlator_0_0, '1', qtgui_time_sink_x_0_2_0_0_0_0, '1']
- [base_code_correlator_0_0_0, '0', blocks_null_sink_4_2_0_0, '0']
- [base_code_correlator_0_0_0, '1', qtgui_time_sink_x_0_2_0_0_0_0, '2']
- [base_code_correlator_0_0_0_0, '0', blocks_null_sink_4_2_0_0_0, '0']
- [base_code_correlator_0_0_0_0, '1', qtgui_time_sink_x_0_2_0_0_0_0, '3']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_1_0_1, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0_0_0_0_0_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', digital_constellation_decoder_cb_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', digital_constellation_decoder_cb_0_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0_0, '0', digital_constellation_decoder_cb_0_0_0, '0']
- [blocks_multiply_const_vxx_1_1, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_xx_0, '0', analog_agc_xx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_repack_bits_bb_1_0_0_0_0, '0', digital_crc32_bb_0_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', blocks_uchar_to_float_0_0_1_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', digital_correlate_access_code_xx_ts_0_0_0, '0']
- [blocks_repack_bits_bb_1_0_1, '0', qtgui_time_raster_sink_x_0_1_0_0, '0']
- [blocks_skiphead_0_0, '0', digital_symbol_sync_xx_0, '0']
- [blocks_uchar_to_float_0_0_0_0_0, '0', qtgui_time_sink_x_0_0_0_0_1, '0']
- [blocks_uchar_to_float_0_0_1_0, '0', qtgui_time_sink_x_0_2_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', virtual_sink_1, '0']
- [blocks_unpacked_to_packed_xx_0_0, '0', virtual_sink_1_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_0, '0', virtual_sink_1_0_0, '0']
- [blocks_unpacked_to_packed_xx_0_0_1, '0', virtual_sink_1_0_1, '0']
- [blocks_unpacked_to_packed_xx_0_0_2, '0', virtual_sink_1_0_2, '0']
- [blocks_unpacked_to_packed_xx_0_1, '0', virtual_sink_1_0_3, '0']
- [correlate_and_crc_validate_0, '0', blocks_null_sink_4, '0']
- [correlate_and_crc_validate_0, '1', qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0, '0']
- [correlate_and_crc_validate_0_0, '0', blocks_null_sink_4_0, '0']
- [correlate_and_crc_validate_0_0, '1', qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0_0, '0']
- [correlate_and_crc_validate_0_0_0, '0', blocks_null_sink_4_0_0, '0']
- [correlate_and_crc_validate_0_0_0, '1', qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0_0_0, '0']
- [correlate_and_crc_validate_0_1, '0', blocks_null_sink_4_1, '0']
- [correlate_and_crc_validate_0_1, '1', qtgui_time_sink_x_0_0_0_0_0_0_1_0_1_0_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0_0, '0']
- [digital_constellation_decoder_cb_0_0, '0', blocks_unpacked_to_packed_xx_0_0_1, '0']
- [digital_constellation_decoder_cb_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0_2, '0']
- [digital_constellation_decoder_cb_0_0_0_0, '0', blocks_unpacked_to_packed_xx_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_receiver_cb_0, '1', blocks_null_sink_0_0_0, '0']
- [digital_constellation_receiver_cb_0, '2', blocks_null_sink_0_0, '0']
- [digital_constellation_receiver_cb_0, '3', blocks_null_sink_0, '0']
- [digital_constellation_receiver_cb_0, '4', qtgui_const_sink_x_1, '1']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_repack_bits_bb_1_0_0_0_0, '0']
- [digital_correlate_access_code_xx_ts_0_0_0, '0', blocks_uchar_to_float_0_0_0_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_multiply_const_vxx_1_1, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_1_0, '1']
- [digital_costas_loop_cc_0, '1', blocks_null_sink_2, '0']
- [digital_costas_loop_cc_0, '2', blocks_null_sink_3, '0']
- [digital_costas_loop_cc_0, '3', blocks_null_sink_1, '0']
- [digital_crc32_bb_0_0_0_0, '0', blocks_char_to_float_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_crc32_bb_0_0_0_0, '0', epy_block_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_char_to_float_0_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_diff_decoder_bb_0_0, '0', blocks_unpacked_to_packed_xx_0_1, '0']
- [digital_fll_band_edge_cc_0, '0', blocks_skiphead_0_0, '0']
- [digital_fll_band_edge_cc_0, '0', qtgui_freq_sink_x_0, '2']
- [digital_symbol_sync_xx_0, '0', digital_constellation_receiver_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_1_0, '0']
- [digital_symbol_sync_xx_0, '1', blocks_null_sink_0_1, '0']
- [digital_symbol_sync_xx_0, '2', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '0']
- [digital_symbol_sync_xx_0, '3', qtgui_time_sink_x_0_0_0_0_0_0_1_0_0, '1']
- [iio_pluto_source_0, '0', blocks_multiply_xx_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [virtual_source_1_0_0, '0', blocks_repack_bits_bb_1_0_1, '0']
- [virtual_source_1_0_0, '0', qtgui_time_raster_sink_x_0_1_0_0_0, '0']
- [virtual_source_1_0_0_0, '0', correlate_and_crc_validate_0, '0']
- [virtual_source_1_0_0_0_0, '0', correlate_and_crc_validate_0_0, '0']
- [virtual_source_1_0_0_0_0_0, '0', correlate_and_crc_validate_0_0_0, '0']
- [virtual_source_1_0_0_0_1, '0', correlate_and_crc_validate_0_1, '0']
- [virtual_source_1_0_0_0_2, '0', base_code_correlator_0, '0']
- [virtual_source_1_0_0_0_2_0, '0', base_code_correlator_0_0, '0']
- [virtual_source_1_0_0_0_2_0_0, '0', base_code_correlator_0_0_0, '0']
- [virtual_source_1_0_0_0_2_0_0_0, '0', base_code_correlator_0_0_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
